# Keil uVision project usbaudio.uvproj, settings and files
target Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: usbaudio +hex
  c flags: Optim=1
  c include: .\common\inc;.\common\src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  scatter file: .\DMA.sct
  group Source Files
    ./: usbuser.c usbcore.c usbdesc.c usbdmain.c usbhw.c adcuser.c
  group Startup Files
    ./: system_LPC17xx.c core_cm3.c startup_LPC17xx.s
  group Files
    ./: ADC.c adcuser.c ARM_Ani_16bpp.c background.c Bg_16bpp_b.c Bg_16bpp_l.c Bg_16bpp_r.c Bg_16bpp_t.c char.c core_cm3.c GLCD_SPI_LPC1700.c IRQ.c KBD.c LED.c system_LPC17xx.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c
    ./inc/: core_cm3.h LPC17xx.h system_LPC17xx.h type.h
    ./src/: startup_LPC17xx.s
    S:/Desktop/: bird_dead.C bird_down.C bird_up.C bird-mid.C pipe1.C pipe2.C pipe3.C logo.c
    S:/Desktop/Desktop 11-15-17/: foreground.c
